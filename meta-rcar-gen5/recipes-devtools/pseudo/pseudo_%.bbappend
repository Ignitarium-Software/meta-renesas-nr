FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-Avoid-openat2-via-syscall-CVE-2025-45582.patch"
